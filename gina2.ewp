# IAR project gina2.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: GINA_VERSION_2_2C
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    commands/: commands.c
    drivers/: gina.c gyro.c i2c.c large_range_accel.c magnetometer.c pwm.c radio.c sensitive_accel_temperature.c usb.c util.c
    ./: main.c
