<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iar_projects\gina2.2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\test_imu_radio.ewp</path>
  </project>
  <batchBuild/>
</workspace>


